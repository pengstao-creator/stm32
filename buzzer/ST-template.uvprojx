# Keil uVision project ST-template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST-template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Lib\CMSIS;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\User;.\public;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Lib/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Lib/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_gpio.h misc.h
    ./Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c
  group CMSIS
    ./Lib/CMSIS/: core_cm3.c system_stm32f10x.c
  group public
    ../fw_oper_led/public/: timeDelay.h timeDelay.c
    ./public/: system.h
  group APP
    ./App/: buzz.c buzz.h smg.h smg.c key.c computer.c computer.h matrixKey.c matrixKey.h key.h bindKey.c bindKey.h
